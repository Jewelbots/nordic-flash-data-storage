# Keil uVision project jwb_s130.uvprojx, settings and files
target Jewelbot_Release (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: jwb_s130 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: SOFTDEVICE_PRESENT NRF51 BLE_STACK_SUPPORT_REQD S130 SIMULATE_BATTERY
  c include: .\segger\RTT;.\nrf51_sdk\components;.\nrf51_sdk\components\ble;.\nrf51_sdk\components\ble\ble_advertising;.\nrf51_sdk\components\ble\ble_debug_assert_handler;.\nrf51_sdk\components\ble\ble_error_log;.\nrf51_sdk\components\ble\ble_radio_notification;.\nrf51_sdk\components\ble\ble_services;.\nrf51_sdk\components\ble\common;.\nrf51_sdk\components\ble\peer_manager;.\nrf51_sdk\components\device;.\nrf51_sdk\components\drivers_nrf;.\nrf51_sdk\components\drivers_nrf\ble_flash;.\nrf51_sdk\components\drivers_nrf\clock;.\nrf51_sdk\components\drivers_nrf\common;.\nrf51_sdk\components\drivers_nrf\config;.\nrf51_sdk\components\drivers_nrf\delay;.\nrf51_sdk\components\drivers_nrf\gpiote;.\nrf51_sdk\components\drivers_nrf\hal;.\nrf51_sdk\components\drivers_nrf\pstorage\config;.\nrf51_sdk\components\drivers_nrf\pstorage;.\nrf51_sdk\components\drivers_nrf\radio_config;.\nrf51_sdk\components\drivers_nrf\rng;.\nrf51_sdk\components\drivers_nrf\spi_master;.\nrf51_sdk\components\drivers_nrf\timer;.\nrf51_sdk\components\drivers_nrf\twi_master;.\nrf51_sdk\components\drivers_nrf\uart;.\nrf51_sdk\components\drivers_nrf\wdt;.\nrf51_sdk\components\libraries;.\nrf51_sdk\components\libraries\button;.\nrf51_sdk\components\libraries\gpiote;.\nrf51_sdk\components\libraries\hci;.\nrf51_sdk\components\libraries\hci\config;.\nrf51_sdk\components\libraries\ic_info;.\nrf51_sdk\components\libraries\scheduler;.\nrf51_sdk\components\libraries\timer;.\nrf51_sdk\components\libraries\twi;.\nrf51_sdk\components\libraries\uart;.\nrf51_sdk\components\libraries\util;.\nrf51_sdk\components\softdevice\s130\hex;.\nrf51_sdk\components\softdevice\s130\headers;.\nrf51_sdk\components\softdevice\common;.\nrf51_sdk\components\softdevice;.\nrf51_sdk\components\softdevice\common\softdevice_handler;.\nrf51_sdk\components\ble\ble_db_discovery;.\nrf51_sdk\components\libraries\fds;.\nrf51_sdk\components\libraries\fstorage;.\nrf51_sdk\components\libraries\hci;.\nrf51_sdk\components\libraries\mem_manager;.\nrf51_sdk\components\libraries\trace;.\nrf51_sdk\components\libraries\crc16;.\nrf51_sdk\components\libraries\experimental_section_vars;.\
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Source
    ./: main.c friend_data_storage.c
  group RTT
    ./segger/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ./segger/Syscalls/: RTT_Syscalls_KEIL.c
  group Drivers
    ./nrf51_sdk/components/drivers_nrf/common/: nrf_drv_common.c
    ./nrf51_sdk/components/drivers_nrf/delay/: nrf_delay.c
  group Libraries
    ./nrf51_sdk/components/libraries/scheduler/: app_scheduler.c
    ./nrf51_sdk/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ./nrf51_sdk/components/libraries/fstorage/: fstorage.c
    ./nrf51_sdk/components/libraries/ic_info/: nrf51_ic_info.c
    ./nrf51_sdk/components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c nrf_log.c sdk_mapped_flags.c
    ./nrf51_sdk/components/libraries/fds/: fds.c
  group Softdevice
    ./nrf51_sdk/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.0.5
